*SPICE Netlist for circuit 615
R1 0 4 1k
R2 0 2 1k
M2 3 1 VDD VDD PMOS W=1u L=1u
R3 4 2 1k
M3 2 3 VDD VDD PMOS W=1u L=1u
M1 3 6 4 4 NMOS W=1u L=1u
.MODEL NMOS NMOS (LEVEL=1 VTO=1 KP=1.0e-4 LAMBDA=0.02)
.MODEL PMOS PMOS (LEVEL=1 VTO=1 KP=1.0e-4 LAMBDA=0.02)

.OP
.END
