*SPICE Netlist for circuit 747
I1 3 0 DC 1mA
M5 12 1 VDD 13 13 PMOS W=1u L=1u
M1 6 2 14 15 15 NMOS W=1u L=1u
M4 14 11 3 3 NMOS W=1u L=1u
M2 16 9 3 3 NMOS W=1u L=1u
M6 6 4 12 12 PMOS W=1u L=1u
M8 7 4 17 17 PMOS W=1u L=1u
M3 7 2 16 16 NMOS W=1u L=1u
M7 17 1 VDD VDD PMOS W=1u L=1u
.MODEL NMOS NMOS (LEVEL=1 VTO=1 KP=1.0e-4 LAMBDA=0.02)
.MODEL PMOS PMOS (LEVEL=1 VTO=1 KP=1.0e-4 LAMBDA=0.02)

.OP
.END
