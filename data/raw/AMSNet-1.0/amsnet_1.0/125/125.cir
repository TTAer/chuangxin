*SPICE Netlist for circuit 125
I1 2 0 DC 1mA
R1 0 2 1k
M1 3 5 2 2 NMOS W=1u L=1u
R2 3 VDD 1k
.MODEL NMOS NMOS (LEVEL=1 VTO=1 KP=1.0e-4 LAMBDA=0.02)

.OP
.END
