*SPICE Netlist for circuit 613
C1 4 2 1nF
C2 2 1 1nF
M1 1 2 0 0 NMOS W=1u L=1u
M2 1 2 VDD VDD PMOS W=1u L=1u
.MODEL NMOS NMOS (LEVEL=1 VTO=1 KP=1.0e-4 LAMBDA=0.02)
.MODEL PMOS PMOS (LEVEL=1 VTO=1 KP=1.0e-4 LAMBDA=0.02)

.OP
.END
