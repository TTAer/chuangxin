*SPICE Netlist for circuit 204
M2 1 5 0 0 NMOS W=1u L=1u
M1 2 6 0 0 NMOS W=1u L=1u
V2 5 0 5V
V1 6 0 5V
R2 1 VDD 1k
R1 2 VDD 1k
.MODEL NMOS NMOS (LEVEL=1 VTO=1 KP=1.0e-4 LAMBDA=0.02)

.OP
.END
