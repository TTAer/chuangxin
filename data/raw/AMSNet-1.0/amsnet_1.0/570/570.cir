*SPICE Netlist for circuit 570
C1 4 2 1nF
I1 4 0 DC 1mA
I2 0 3 DC 1mA
M2 2 3 0 0 NMOS W=1u L=1u
R2 3 4 1k
M1 VDD 2 4 4 NMOS W=1u L=1u
R1 2 VDD 1k
.MODEL NMOS NMOS (LEVEL=1 VTO=1 KP=1.0e-4 LAMBDA=0.02)

.OP
.END
