*SPICE Netlist for circuit 704
C1 0 10 1nF
C2 0 7 1nF
I1 4 0 DC 1mA
I2 1 0 DC 1mA
M1 17 14 1 21 21 NMOS W=1u L=1u
M5 2 2 VDD VDD PMOS W=1u L=1u
M7 3 2 VDD VDD PMOS W=1u L=1u
M6 6 3 VDD VDD PMOS W=1u L=1u
M8 3 3 VDD VDD PMOS W=1u L=1u
M4 10 14 4 4 NMOS W=1u L=1u
M3 7 12 4 4 NMOS W=1u L=1u
M2 6 12 1 22 22 NMOS W=1u L=1u
.MODEL NMOS NMOS (LEVEL=1 VTO=1 KP=1.0e-4 LAMBDA=0.02)
.MODEL PMOS PMOS (LEVEL=1 VTO=1 KP=1.0e-4 LAMBDA=0.02)

.OP
.END
