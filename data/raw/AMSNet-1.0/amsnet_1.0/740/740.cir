*SPICE Netlist for circuit 740
C1 0 1 1nF
C2 0 6 1nF
C3 0 4 1nF
I1 4 0 DC 1mA
I2 0 6 DC 1mA
M2 1 6 0 0 NMOS W=1u L=1u
M1 VDD 1 4 4 NMOS W=1u L=1u
R2 6 4 1k
R1 1 VDD 1k
.MODEL NMOS NMOS (LEVEL=1 VTO=1 KP=1.0e-4 LAMBDA=0.02)

.OP
.END
