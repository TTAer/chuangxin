*SPICE Netlist for circuit 110
C1 0 3 1nF
I1 3 0 DC 1mA
M2 1 1 VDD VDD PMOS W=1u L=1u
M1 1 5 3 3 NMOS W=1u L=1u
.MODEL NMOS NMOS (LEVEL=1 VTO=1 KP=1.0e-4 LAMBDA=0.02)
.MODEL PMOS PMOS (LEVEL=1 VTO=1 KP=1.0e-4 LAMBDA=0.02)

.OP
.END
