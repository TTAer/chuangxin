*SPICE Netlist for circuit 305
C1 8 1 1nF
I1 VDD 3 DC 1mA
I2 4 0 DC 1mA
M2 6 1 0 0 NMOS W=1u L=1u
M1 3 3 0 0 NMOS W=1u L=1u
R1 3 1 1k
M3 4 4 9 9 PMOS W=1u L=1u
M4 6 4 9 9 PMOS W=1u L=1u
.MODEL NMOS NMOS (LEVEL=1 VTO=1 KP=1.0e-4 LAMBDA=0.02)
.MODEL PMOS PMOS (LEVEL=1 VTO=1 KP=1.0e-4 LAMBDA=0.02)

.OP
.END
