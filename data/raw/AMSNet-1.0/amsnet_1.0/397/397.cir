*SPICE Netlist for circuit 397
C1 0 2 1nF
C2 0 3 1nF
M1 2 7 0 0 NMOS W=1u L=1u
M2 3 2 0 0 NMOS W=1u L=1u
M3 2 1 VDD 8 8 PMOS W=1u L=1u
M4 3 1 VDD VDD PMOS W=1u L=1u
.MODEL NMOS NMOS (LEVEL=1 VTO=1 KP=1.0e-4 LAMBDA=0.02)
.MODEL PMOS PMOS (LEVEL=1 VTO=1 KP=1.0e-4 LAMBDA=0.02)

.OP
.END
