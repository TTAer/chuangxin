*SPICE Netlist for circuit 431
R1 1 2 1k
R2 2 1 1k

.OP
.END
