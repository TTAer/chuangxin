*SPICE Netlist for circuit 13
M2 4 1 2 2 NMOS W=1u L=1u
M1 3 6 1 1 NMOS W=1u L=1u
M3 1 7 2 2 NMOS W=1u L=1u
.MODEL NMOS NMOS (LEVEL=1 VTO=1 KP=1.0e-4 LAMBDA=0.02)

.OP
.END
