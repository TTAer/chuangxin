*SPICE Netlist for circuit 589
I1 0 2 DC 1mA
M2 3 2 0 0 NMOS W=1u L=1u
R2 0 2 1k
M1 VDD 3 2 2 NMOS W=1u L=1u
R1 3 VDD 1k
.MODEL NMOS NMOS (LEVEL=1 VTO=1 KP=1.0e-4 LAMBDA=0.02)

.OP
.END
