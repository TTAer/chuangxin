*SPICE Netlist for circuit 427
C1 2 1 1nF
R1 2 1 1k

.OP
.END
