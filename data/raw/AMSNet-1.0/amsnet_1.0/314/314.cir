*SPICE Netlist for circuit 314
C1 8 4 1nF
R2 9 8 1k
I1 VDD 3 DC 1mA
V1 9 0 5V
M3 4 3 0 0 NMOS W=1u L=1u
M4 10 3 0 0 NMOS W=1u L=1u
M1 3 11 10 1 1 NMOS W=1u L=1u
M2 5 11 4 4 NMOS W=1u L=1u
R1 5 VDD 1k
.MODEL NMOS NMOS (LEVEL=1 VTO=1 KP=1.0e-4 LAMBDA=0.02)

.OP
.END
