*SPICE Netlist for circuit 313
C1 7 3 1nF
R2 8 7 1k
I1 VDD 4 DC 1mA
V1 8 0 5V
M2 3 4 0 0 NMOS W=1u L=1u
M3 4 4 0 0 NMOS W=1u L=1u
M1 5 1 3 3 NMOS W=1u L=1u
R1 5 VDD 1k
.MODEL NMOS NMOS (LEVEL=1 VTO=1 KP=1.0e-4 LAMBDA=0.02)

.OP
.END
