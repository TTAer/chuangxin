*SPICE Netlist for circuit 656
I1 3 0 DC 1mA
M2 1 1 3 3 NMOS W=1u L=1u
R1 1 VDD 1k
M1 2 2 3 3 NMOS W=1u L=1u
R2 2 VDD 1k
.MODEL NMOS NMOS (LEVEL=1 VTO=1 KP=1.0e-4 LAMBDA=0.02)

.OP
.END
