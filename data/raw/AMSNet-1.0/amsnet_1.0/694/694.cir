*SPICE Netlist for circuit 694
C1 0 1 1nF
M5 1 21 0 0 NMOS W=1u L=1u
M4 22 5 0 0 NMOS W=1u L=1u
M2 3 8 2 2 NMOS W=1u L=1u
M1 1 14 3 3 NMOS W=1u L=1u
M3 5 19 22 22 NMOS W=1u L=1u
.MODEL NMOS NMOS (LEVEL=1 VTO=1 KP=1.0e-4 LAMBDA=0.02)

.OP
.END
