*SPICE Netlist for circuit 515
M2 3 6 0 0 NMOS W=1u L=1u
M3 3 1 VDD VDD PMOS W=1u L=1u
M1 4 2 3 3 NMOS W=1u L=1u
R1 4 VDD 1k
.MODEL NMOS NMOS (LEVEL=1 VTO=1 KP=1.0e-4 LAMBDA=0.02)
.MODEL PMOS PMOS (LEVEL=1 VTO=1 KP=1.0e-4 LAMBDA=0.02)

.OP
.END
