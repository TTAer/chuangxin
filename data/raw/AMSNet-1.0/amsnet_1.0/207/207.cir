*SPICE Netlist for circuit 207
I1 2 0 DC 1mA
V1 3 0 5V
R2 2 1 1k
R1 1 VDD 1k
M2 1 3 2 2 NMOS W=1u L=1u
M1 6 3 2 2 NMOS W=1u L=1u
R3 6 2 1k
R4 6 VDD 1k
.MODEL NMOS NMOS (LEVEL=1 VTO=1 KP=1.0e-4 LAMBDA=0.02)

.OP
.END
