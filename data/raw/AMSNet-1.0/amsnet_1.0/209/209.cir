*SPICE Netlist for circuit 209
I1 2 0 DC 1mA
I2 1 0 DC 1mA
R3 2 1 1k
M1 5 3 1 1 NMOS W=1u L=1u
M2 6 4 2 2 NMOS W=1u L=1u
R2 5 VDD 1k
R1 6 VDD 1k
.MODEL NMOS NMOS (LEVEL=1 VTO=1 KP=1.0e-4 LAMBDA=0.02)

.OP
.END
