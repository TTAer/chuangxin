*SPICE Netlist for circuit 246
M5 3 5 0 0 NMOS W=1u L=1u
M7 1 1 VDD VDD PMOS W=1u L=1u
M1 1 4 7 12 12 NMOS W=1u L=1u
M6 2 2 VDD VDD PMOS W=1u L=1u
M3 2 4 6 6 NMOS W=1u L=1u
M4 7 11 3 3 NMOS W=1u L=1u
M2 6 9 3 3 NMOS W=1u L=1u
R1 7 6 1k
.MODEL NMOS NMOS (LEVEL=1 VTO=1 KP=1.0e-4 LAMBDA=0.02)
.MODEL PMOS PMOS (LEVEL=1 VTO=1 KP=1.0e-4 LAMBDA=0.02)

.OP
.END
