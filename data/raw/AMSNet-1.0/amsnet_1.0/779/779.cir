*SPICE Netlist for circuit 779
C1 0 2 1nF
M1 0 1 2 2 PMOS W=1u L=1u
.MODEL PMOS PMOS (LEVEL=1 VTO=1 KP=1.0e-4 LAMBDA=0.02)

.OP
.END
