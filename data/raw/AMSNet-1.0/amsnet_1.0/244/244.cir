*SPICE Netlist for circuit 244
M3 1 2 0 0 NMOS W=1u L=1u
M2 5 10 1 1 NMOS W=1u L=1u
M1 3 8 1 1 NMOS W=1u L=1u
M5 3 5 VDD VDD PMOS W=1u L=1u
M4 5 3 VDD VDD PMOS W=1u L=1u
.MODEL NMOS NMOS (LEVEL=1 VTO=1 KP=1.0e-4 LAMBDA=0.02)
.MODEL PMOS PMOS (LEVEL=1 VTO=1 KP=1.0e-4 LAMBDA=0.02)

.OP
.END
