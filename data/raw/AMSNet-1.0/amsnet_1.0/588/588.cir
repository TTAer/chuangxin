*SPICE Netlist for circuit 588
M2 1 2 0 0 NMOS W=1u L=1u
R2 0 2 1k
R1 1 VDD 1k
M1 VDD 4 2 2 NMOS W=1u L=1u
.MODEL NMOS NMOS (LEVEL=1 VTO=1 KP=1.0e-4 LAMBDA=0.02)

.OP
.END
