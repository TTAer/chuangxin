*SPICE Netlist for circuit 822
M1 2 1 0 10 10 NMOS W=1u L=1u
M6 3 1 0 0 NMOS W=1u L=1u
M4 5 8 2 2 NMOS W=1u L=1u
M2 4 9 2 2 NMOS W=1u L=1u
M5 11 4 3 3 NMOS W=1u L=1u
M3 12 5 3 3 NMOS W=1u L=1u
R2 4 VDD 1k
R1 5 VDD 1k
R4 12 VDD 1k
R3 11 VDD 1k
.MODEL NMOS NMOS (LEVEL=1 VTO=1 KP=1.0e-4 LAMBDA=0.02)

.OP
.END
