*SPICE Netlist for circuit 545
C1 2 1 1nF
C2 0 2 1nF
V1 1 0 5V
R1 0 4 1k
M1 4 2 0 0 NMOS W=1u L=1u
M2 1 0 4 4 NMOS W=1u L=1u
R2 1 VDD 1k
.MODEL NMOS NMOS (LEVEL=1 VTO=1 KP=1.0e-4 LAMBDA=0.02)

.OP
.END
