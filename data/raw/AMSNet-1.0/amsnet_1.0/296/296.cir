*SPICE Netlist for circuit 296
I1 4 0 DC 1mA
I2 3 0 DC 1mA
V1 2 0 5V
M3 4 4 VDD VDD NMOS W=1u L=1u
M4 6 4 VDD VDD PMOS W=1u L=1u
M2 6 2 3 3 NMOS W=1u L=1u
M1 7 2 3 3 NMOS W=1u L=1u
M5 7 8 VDD VDD PMOS W=1u L=1u
.MODEL NMOS NMOS (LEVEL=1 VTO=1 KP=1.0e-4 LAMBDA=0.02)
.MODEL PMOS PMOS (LEVEL=1 VTO=1 KP=1.0e-4 LAMBDA=0.02)

.OP
.END
