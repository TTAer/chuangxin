*SPICE Netlist for circuit 715
M1 5 2 0 10 10 NMOS W=1u L=1u
M2 4 2 0 0 NMOS W=1u L=1u
M4 5 1 VDD VDD PMOS W=1u L=1u
M3 4 3 VDD VDD PMOS W=1u L=1u
.MODEL NMOS NMOS (LEVEL=1 VTO=1 KP=1.0e-4 LAMBDA=0.02)
.MODEL PMOS PMOS (LEVEL=1 VTO=1 KP=1.0e-4 LAMBDA=0.02)

.OP
.END
