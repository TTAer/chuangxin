*SPICE Netlist for circuit 728
C1 3 1 1nF
I1 VDD 1 DC 1mA
I2 3 0 DC 1mA
M1 1 3 0 0 NMOS W=1u L=1u
R1 0 1 1k
.MODEL NMOS NMOS (LEVEL=1 VTO=1 KP=1.0e-4 LAMBDA=0.02)

.OP
.END
