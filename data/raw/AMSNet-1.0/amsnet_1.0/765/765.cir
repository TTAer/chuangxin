*SPICE Netlist for circuit 765
M1 2 2 0 0 NMOS W=1u L=1u
R1 0 7 1k
M4 2 1 VDD VDD NMOS W=1u L=1u
M5 1 1 VDD VDD PMOS W=1u L=1u
M3 1 2 7 7 NMOS W=1u L=1u
M2 1 1 2 2 NMOS W=1u L=1u
.MODEL NMOS NMOS (LEVEL=1 VTO=1 KP=1.0e-4 LAMBDA=0.02)
.MODEL PMOS PMOS (LEVEL=1 VTO=1 KP=1.0e-4 LAMBDA=0.02)

.OP
.END
