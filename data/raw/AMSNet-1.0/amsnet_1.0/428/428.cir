*SPICE Netlist for circuit 428
C1 2 1 1nF
R1 5 1 1k
V1 5 2 5V

.OP
.END
