*SPICE Netlist for circuit 76
I1 1 3 DC 1mA
I2 1 3 DC 1mA
V1 3 0 5V

.OP
.END
