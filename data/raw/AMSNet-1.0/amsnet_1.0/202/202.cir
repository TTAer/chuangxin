*SPICE Netlist for circuit 202
I1 1 0 DC 1mA
V2 6 0 5V
V1 8 0 5V

.OP
.END
