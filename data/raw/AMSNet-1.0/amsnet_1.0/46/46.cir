*SPICE Netlist for circuit 46
C1 0 1 1nF
C2 0 3 1nF
I1 3 1 DC 1mA
M1 3 1 0 0 NMOS W=1u L=1u
.MODEL NMOS NMOS (LEVEL=1 VTO=1 KP=1.0e-4 LAMBDA=0.02)

.OP
.END
