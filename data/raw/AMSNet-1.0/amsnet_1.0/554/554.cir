*SPICE Netlist for circuit 554
C1 5 1 1nF
C2 8 5 1nF
I1 3 0 DC 1mA
M3 1 2 VDD VDD PMOS W=1u L=1u
M2 1 5 3 3 NMOS W=1u L=1u
M4 2 2 VDD VDD PMOS W=1u L=1u
M1 2 4 3 3 NMOS W=1u L=1u
.MODEL NMOS NMOS (LEVEL=1 VTO=1 KP=1.0e-4 LAMBDA=0.02)
.MODEL PMOS PMOS (LEVEL=1 VTO=1 KP=1.0e-4 LAMBDA=0.02)

.OP
.END
