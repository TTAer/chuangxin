*SPICE Netlist for circuit 423
C1 0 2 1nF
C2 3 4 1nF
I1 VDD 2 DC 1mA
M2 4 3 0 0 NMOS W=1u L=1u
M1 2 1 4 4 NMOS W=1u L=1u
.MODEL NMOS NMOS (LEVEL=1 VTO=1 KP=1.0e-4 LAMBDA=0.02)

.OP
.END
