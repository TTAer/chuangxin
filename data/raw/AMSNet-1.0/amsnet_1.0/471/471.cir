*SPICE Netlist for circuit 471
C1 0 1 1nF
I1 VDD 1 DC 1mA
I2 2 0 DC 1mA
M2 2 1 0 0 NMOS W=1u L=1u
M3 1 1 0 0 NMOS W=1u L=1u
M1 6 3 2 2 NMOS W=1u L=1u
R1 6 VDD 1k
.MODEL NMOS NMOS (LEVEL=1 VTO=1 KP=1.0e-4 LAMBDA=0.02)

.OP
.END
