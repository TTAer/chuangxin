*SPICE Netlist for circuit 544
C1 2 1 1nF
C2 0 2 1nF
R1 0 4 1k
M1 4 2 0 0 NMOS W=1u L=1u
R2 1 VDD 1k
M2 1 6 4 4 NMOS W=1u L=1u
.MODEL NMOS NMOS (LEVEL=1 VTO=1 KP=1.0e-4 LAMBDA=0.02)

.OP
.END
