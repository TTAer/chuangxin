*SPICE Netlist for circuit 744
I1 15 0 DC 1mA
M4 18 4 0 0 NMOS W=1u L=1u
M2 19 4 0 20 20 NMOS W=1u L=1u
M7 8 1 6 21 21 PMOS W=1u L=1u
M1 8 2 18 22 22 NMOS W=1u L=1u
M5 13 16 3 3 NMOS W=1u L=1u
M3 6 11 3 3 NMOS W=1u L=1u
M8 5 VDD VDD VDD PMOS W=1u L=1u
M10 7 1 5 5 PMOS W=1u L=1u
M6 7 2 19 19 NMOS W=1u L=1u
M9 5 17 14 14 PMOS W=1u L=1u
.MODEL NMOS NMOS (LEVEL=1 VTO=1 KP=1.0e-4 LAMBDA=0.02)
.MODEL PMOS PMOS (LEVEL=1 VTO=1 KP=1.0e-4 LAMBDA=0.02)

.OP
.END
