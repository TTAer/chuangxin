*SPICE Netlist for circuit 455
V1 6 0 5V

.OP
.END
