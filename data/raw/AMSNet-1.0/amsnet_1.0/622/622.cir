*SPICE Netlist for circuit 622
C1 0 3 1nF
M1 2 4 0 0 NMOS W=1u L=1u
M2 2 1 VDD VDD PMOS W=1u L=1u
R2 3 2 1k
R1 4 3 1k
R3 6 4 1k
.MODEL NMOS NMOS (LEVEL=1 VTO=1 KP=1.0e-4 LAMBDA=0.02)
.MODEL PMOS PMOS (LEVEL=1 VTO=1 KP=1.0e-4 LAMBDA=0.02)

.OP
.END
