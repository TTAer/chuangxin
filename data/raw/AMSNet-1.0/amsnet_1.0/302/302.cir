*SPICE Netlist for circuit 302
C1 8 1 1nF
I1 VDD 2 DC 1mA
M4 5 1 0 0 NMOS W=1u L=1u
M2 3 3 0 0 NMOS W=1u L=1u
M3 3 2 1 1 NMOS W=1u L=1u
M1 2 2 3 3 NMOS W=1u L=1u
R1 5 VDD 1k
.MODEL NMOS NMOS (LEVEL=1 VTO=1 KP=1.0e-4 LAMBDA=0.02)

.OP
.END
