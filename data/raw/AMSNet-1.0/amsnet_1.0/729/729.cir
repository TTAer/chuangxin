*SPICE Netlist for circuit 729
C1 2 1 1nF
I1 6 0 DC 1mA
M1 1 4 6 6 NMOS W=1u L=1u
I2 5 0 DC 1mA
M2 2 1 VDD VDD PMOS W=1u L=1u
.MODEL NMOS NMOS (LEVEL=1 VTO=1 KP=1.0e-4 LAMBDA=0.02)
.MODEL PMOS PMOS (LEVEL=1 VTO=1 KP=1.0e-4 LAMBDA=0.02)

.OP
.END
