*SPICE Netlist for circuit 185
M1 7 1 6 6 NMOS W=1u L=1u
M2 6 2 4 4 NMOS W=1u L=1u
.MODEL NMOS NMOS (LEVEL=1 VTO=1 KP=1.0e-4 LAMBDA=0.02)

.OP
.END
