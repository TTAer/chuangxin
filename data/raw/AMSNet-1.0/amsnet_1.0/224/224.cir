*SPICE Netlist for circuit 224
I1 3 0 DC 1mA
M5 1 4 VDD VDD PMOS W=1u L=1u
M4 2 5 VDD VDD PMOS W=1u L=1u
M3 1 1 VDD VDD PMOS W=1u L=1u
M6 2 2 VDD VDD PMOS W=1u L=1u
M2 1 10 3 3 NMOS W=1u L=1u
M1 2 11 3 3 NMOS W=1u L=1u
.MODEL NMOS NMOS (LEVEL=1 VTO=1 KP=1.0e-4 LAMBDA=0.02)
.MODEL PMOS PMOS (LEVEL=1 VTO=1 KP=1.0e-4 LAMBDA=0.02)

.OP
.END
