*SPICE Netlist for circuit 290
M2 5 3 2 2 NMOS W=1u L=1u
M1 4 3 2 2 NMOS W=1u L=1u
R1 0 2 1k
M3 5 5 VDD VDD NMOS W=1u L=1u
M4 4 5 VDD VDD PMOS W=1u L=1u
.MODEL NMOS NMOS (LEVEL=1 VTO=1 KP=1.0e-4 LAMBDA=0.02)
.MODEL PMOS PMOS (LEVEL=1 VTO=1 KP=1.0e-4 LAMBDA=0.02)

.OP
.END
