*SPICE Netlist for circuit 770
I1 2 0 DC 1mA
R1 2 1 1k
M2 1 2 4 4 PMOS W=1u L=1u
M1 4 1 VDD VDD PMOS W=1u L=1u
.MODEL PMOS PMOS (LEVEL=1 VTO=1 KP=1.0e-4 LAMBDA=0.02)

.OP
.END
