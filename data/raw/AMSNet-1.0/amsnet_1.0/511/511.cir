*SPICE Netlist for circuit 511
M1 2 5 0 0 NMOS W=1u L=1u
R2 0 3 1k
M2 3 1 2 2 NMOS W=1u L=1u
R1 2 VDD 1k
.MODEL NMOS NMOS (LEVEL=1 VTO=1 KP=1.0e-4 LAMBDA=0.02)

.OP
.END
