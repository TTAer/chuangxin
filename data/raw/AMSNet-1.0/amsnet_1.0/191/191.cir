*SPICE Netlist for circuit 191
R3 0 1 1k
M2 3 2 1 1 NMOS W=1u L=1u
M1 4 2 1 1 NMOS W=1u L=1u
R1 3 VDD 1k
R2 4 VDD 1k
.MODEL NMOS NMOS (LEVEL=1 VTO=1 KP=1.0e-4 LAMBDA=0.02)

.OP
.END
