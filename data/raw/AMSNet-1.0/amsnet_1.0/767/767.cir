*SPICE Netlist for circuit 767
I1 1 0 DC 1mA
I2 1 0 DC 1mA
R1 1 VDD 1k

.OP
.END
