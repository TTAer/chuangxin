*SPICE Netlist for circuit 756
C1 0 1 1nF
C2 0 2 1nF
C3 0 2 1nF
C4 2 1 1nF
R1 0 1 1k

.OP
.END
