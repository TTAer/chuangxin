*SPICE Netlist for circuit 172
R1 0 2 1k
M2 1 2 VDD VDD NMOS W=1u L=1u
M1 1 4 2 2 NMOS W=1u L=1u
.MODEL NMOS NMOS (LEVEL=1 VTO=1 KP=1.0e-4 LAMBDA=0.02)

.OP
.END
