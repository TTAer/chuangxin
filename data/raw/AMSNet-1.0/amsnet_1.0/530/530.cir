*SPICE Netlist for circuit 530
M3 2 1 0 0 NMOS W=1u L=1u
R3 10 2 1k
R4 2 11 1k
R2 3 VDD 1k
M1 3 8 11 11 NMOS W=1u L=1u
R1 4 VDD 1k
M2 4 7 10 10 NMOS W=1u L=1u
.MODEL NMOS NMOS (LEVEL=1 VTO=1 KP=1.0e-4 LAMBDA=0.02)

.OP
.END
