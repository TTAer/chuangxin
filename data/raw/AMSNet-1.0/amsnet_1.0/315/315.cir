*SPICE Netlist for circuit 315
I1 VDD 3 DC 1mA
M1 3 3 0 0 NMOS W=1u L=1u
M3 1 3 0 0 NMOS W=1u L=1u
M2 VDD 5 1 1 NMOS W=1u L=1u
.MODEL NMOS NMOS (LEVEL=1 VTO=1 KP=1.0e-4 LAMBDA=0.02)

.OP
.END
