*SPICE Netlist for circuit 346
C1 3 4 1nF
M3 1 1 4 4 PMOS W=1u L=1u
M1 1 5 0 6 6 NMOS W=1u L=1u
M2 5 1 VDD VDD NMOS W=1u L=1u
.MODEL NMOS NMOS (LEVEL=1 VTO=1 KP=1.0e-4 LAMBDA=0.02)
.MODEL PMOS PMOS (LEVEL=1 VTO=1 KP=1.0e-4 LAMBDA=0.02)

.OP
.END
