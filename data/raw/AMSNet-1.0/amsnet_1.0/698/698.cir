*SPICE Netlist for circuit 698
M3 1 1 5 5 NMOS W=1u L=1u
M2 1 1 4 4 NMOS W=1u L=1u
M1 4 7 VDD 11 11 NMOS W=1u L=1u
M6 8 10 4 4 PMOS W=1u L=1u
M5 5 7 VDD VDD PMOS W=1u L=1u
M4 9 10 5 12 12 PMOS W=1u L=1u
.MODEL NMOS NMOS (LEVEL=1 VTO=1 KP=1.0e-4 LAMBDA=0.02)
.MODEL PMOS PMOS (LEVEL=1 VTO=1 KP=1.0e-4 LAMBDA=0.02)

.OP
.END
