*SPICE Netlist for circuit 95
I1 1 2 DC 1mA
R1 2 1 1k

.OP
.END
