*SPICE Netlist for circuit 329
I1 VDD 4 DC 1mA
M2 3 4 0 0 NMOS W=1u L=1u
M1 4 4 0 0 NMOS W=1u L=1u
R2 4 3 1k
R1 3 VDD 1k
.MODEL NMOS NMOS (LEVEL=1 VTO=1 KP=1.0e-4 LAMBDA=0.02)

.OP
.END
