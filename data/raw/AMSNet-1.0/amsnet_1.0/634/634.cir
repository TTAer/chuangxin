*SPICE Netlist for circuit 634
I1 1 0 DC 1mA
M2 1 2 5 5 PMOS W=1u L=1u
M1 5 4 VDD VDD PMOS W=1u L=1u
.MODEL PMOS PMOS (LEVEL=1 VTO=1 KP=1.0e-4 LAMBDA=0.02)

.OP
.END
