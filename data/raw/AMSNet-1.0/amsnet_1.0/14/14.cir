*SPICE Netlist for circuit 14
C1 2 6 1nF
C2 2 1 1nF
C3 1 6 1nF
C4 2 3 1nF
C5 3 6 1nF
M1 1 2 3 3 NMOS W=1u L=1u
.MODEL NMOS NMOS (LEVEL=1 VTO=1 KP=1.0e-4 LAMBDA=0.02)

.OP
.END
