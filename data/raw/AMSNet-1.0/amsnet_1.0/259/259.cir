*SPICE Netlist for circuit 259
I1 VDD 4 DC 1mA
M3 1 4 7 7 NMOS W=1u L=1u
M2 3 3 0 0 NMOS W=1u L=1u
M4 7 3 0 0 NMOS W=1u L=1u
M1 4 4 3 3 NMOS W=1u L=1u
.MODEL NMOS NMOS (LEVEL=1 VTO=1 KP=1.0e-4 LAMBDA=0.02)

.OP
.END
