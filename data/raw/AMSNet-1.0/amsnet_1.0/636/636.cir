*SPICE Netlist for circuit 636
I1 VDD 4 DC 1mA
I2 VDD 3 DC 1mA
I3 2 0 DC 1mA
M1 4 1 10 11 11 NMOS W=1u L=1u
M4 10 7 2 2 NMOS W=1u L=1u
M2 12 8 2 2 NMOS W=1u L=1u
M3 3 1 12 12 NMOS W=1u L=1u
.MODEL NMOS NMOS (LEVEL=1 VTO=1 KP=1.0e-4 LAMBDA=0.02)

.OP
.END
