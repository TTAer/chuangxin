*SPICE Netlist for circuit 15
M1 3 5 1 1 NMOS W=1u L=1u
M2 3 5 1 1 NMOS W=1u L=1u
.MODEL NMOS NMOS (LEVEL=1 VTO=1 KP=1.0e-4 LAMBDA=0.02)

.OP
.END
