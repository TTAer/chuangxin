*SPICE Netlist for circuit 139
V1 3 0 5V
M2 4 2 0 0 NMOS W=1u L=1u
M1 3 1 4 4 NMOS W=1u L=1u
.MODEL NMOS NMOS (LEVEL=1 VTO=1 KP=1.0e-4 LAMBDA=0.02)

.OP
.END
