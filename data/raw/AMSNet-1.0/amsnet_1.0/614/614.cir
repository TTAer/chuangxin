*SPICE Netlist for circuit 614
C1 2 1 1nF
C2 0 2 1nF
I1 VDD 1 DC 1mA
M1 1 2 5 5 NMOS W=1u L=1u
.MODEL NMOS NMOS (LEVEL=1 VTO=1 KP=1.0e-4 LAMBDA=0.02)

.OP
.END
