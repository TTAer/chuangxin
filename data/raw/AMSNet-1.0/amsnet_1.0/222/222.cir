*SPICE Netlist for circuit 222
I1 2 0 DC 1mA
M3 6 1 VDD VDD PMOS W=1u L=1u
M4 4 1 VDD VDD PMOS W=1u L=1u
M2 6 10 2 2 NMOS W=1u L=1u
M1 4 11 2 2 NMOS W=1u L=1u
R1 6 1 1k
R2 1 4 1k
.MODEL NMOS NMOS (LEVEL=1 VTO=1 KP=1.0e-4 LAMBDA=0.02)
.MODEL PMOS PMOS (LEVEL=1 VTO=1 KP=1.0e-4 LAMBDA=0.02)

.OP
.END
