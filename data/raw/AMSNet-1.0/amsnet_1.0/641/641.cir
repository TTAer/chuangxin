*SPICE Netlist for circuit 641
M2 2 0 0 0 PMOS W=1u L=1u
R2 0 2 1k
R1 3 0 1k
M1 3 1 2 2 NMOS W=1u L=1u
.MODEL NMOS NMOS (LEVEL=1 VTO=1 KP=1.0e-4 LAMBDA=0.02)
.MODEL PMOS PMOS (LEVEL=1 VTO=1 KP=1.0e-4 LAMBDA=0.02)

.OP
.END
