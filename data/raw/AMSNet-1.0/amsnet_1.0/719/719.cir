*SPICE Netlist for circuit 719
C1 0 4 1nF
I1 5 0 DC 1mA
M7 4 1 12 12 PMOS W=1u L=1u
M1 3 2 13 14 14 NMOS W=1u L=1u
M5 3 3 VDD VDD PMOS W=1u L=1u
M6 12 3 VDD VDD PMOS W=1u L=1u
M4 13 9 5 5 NMOS W=1u L=1u
M2 15 10 5 5 NMOS W=1u L=1u
M3 4 2 15 15 NMOS W=1u L=1u
.MODEL NMOS NMOS (LEVEL=1 VTO=1 KP=1.0e-4 LAMBDA=0.02)
.MODEL PMOS PMOS (LEVEL=1 VTO=1 KP=1.0e-4 LAMBDA=0.02)

.OP
.END
