*SPICE Netlist for circuit 419
C1 0 3 1nF
C2 4 2 1nF
M2 8 7 0 0 NMOS W=1u L=1u
R2 1 4 1k
M1 2 4 8 8 NMOS W=1u L=1u
M3 2 3 VDD VDD PMOS W=1u L=1u
R1 3 2 1k
.MODEL NMOS NMOS (LEVEL=1 VTO=1 KP=1.0e-4 LAMBDA=0.02)
.MODEL PMOS PMOS (LEVEL=1 VTO=1 KP=1.0e-4 LAMBDA=0.02)

.OP
.END
