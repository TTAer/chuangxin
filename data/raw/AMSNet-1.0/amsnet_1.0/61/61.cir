*SPICE Netlist for circuit 61
M2 5 1 6 6 PMOS W=1u L=1u
V1 6 0 5V
M1 5 1 0 0 NMOS W=1u L=1u
.MODEL NMOS NMOS (LEVEL=1 VTO=1 KP=1.0e-4 LAMBDA=0.02)
.MODEL PMOS PMOS (LEVEL=1 VTO=1 KP=1.0e-4 LAMBDA=0.02)

.OP
.END
