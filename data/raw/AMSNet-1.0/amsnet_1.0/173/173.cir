*SPICE Netlist for circuit 173
M3 1 3 7 7 NMOS W=1u L=1u
M1 1 4 6 6 NMOS W=1u L=1u
M2 7 2 VDD VDD NMOS W=1u L=1u
.MODEL NMOS NMOS (LEVEL=1 VTO=1 KP=1.0e-4 LAMBDA=0.02)

.OP
.END
