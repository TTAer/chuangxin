*SPICE Netlist for circuit 697
M3 1 4 2 2 NMOS W=1u L=1u
M2 1 2 4 4 NMOS W=1u L=1u
M1 2 8 VDD 12 12 NMOS W=1u L=1u
M6 9 11 2 2 PMOS W=1u L=1u
M5 4 8 VDD VDD PMOS W=1u L=1u
M4 10 11 4 13 13 PMOS W=1u L=1u
.MODEL NMOS NMOS (LEVEL=1 VTO=1 KP=1.0e-4 LAMBDA=0.02)
.MODEL PMOS PMOS (LEVEL=1 VTO=1 KP=1.0e-4 LAMBDA=0.02)

.OP
.END
