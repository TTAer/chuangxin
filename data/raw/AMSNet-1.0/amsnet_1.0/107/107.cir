*SPICE Netlist for circuit 107
I1 VDD 2 DC 1mA
M2 2 5 0 0 NMOS W=1u L=1u
M3 3 1 0 0 NMOS W=1u L=1u
M1 VDD 2 3 3 NMOS W=1u L=1u
.MODEL NMOS NMOS (LEVEL=1 VTO=1 KP=1.0e-4 LAMBDA=0.02)

.OP
.END
