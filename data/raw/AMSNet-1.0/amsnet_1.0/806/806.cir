*SPICE Netlist for circuit 806
I1 4 0 DC 1mA
I2 3 0 DC 1mA
R1 1 VDD 1k
M2 1 7 4 4 NMOS W=1u L=1u
R2 2 VDD 1k
M1 2 8 3 3 NMOS W=1u L=1u
R3 4 3 1k
.MODEL NMOS NMOS (LEVEL=1 VTO=1 KP=1.0e-4 LAMBDA=0.02)

.OP
.END
