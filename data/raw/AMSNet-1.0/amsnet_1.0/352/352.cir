*SPICE Netlist for circuit 352
C1 2 4 1nF
I1 2 0 DC 1mA
M2 4 1 2 2 NMOS W=1u L=1u
M1 8 1 2 2 NMOS W=1u L=1u
M3 4 4 VDD VDD NMOS W=1u L=1u
M4 8 4 VDD VDD PMOS W=1u L=1u
.MODEL NMOS NMOS (LEVEL=1 VTO=1 KP=1.0e-4 LAMBDA=0.02)
.MODEL PMOS PMOS (LEVEL=1 VTO=1 KP=1.0e-4 LAMBDA=0.02)

.OP
.END
