*SPICE Netlist for circuit 370
C1 1 2 1nF
C2 0 1 1nF
V1 2 0 5V
R1 0 1 1k
M1 VDD 2 1 1 NMOS W=1u L=1u
.MODEL NMOS NMOS (LEVEL=1 VTO=1 KP=1.0e-4 LAMBDA=0.02)

.OP
.END
