*SPICE Netlist for circuit 692
C1 0 1 1nF
C2 0 2 1nF
I1 3 0 DC 1mA
M6 1 8 12 13 13 PMOS W=1u L=1u
M1 1 9 14 15 15 NMOS W=1u L=1u
M8 2 8 16 16 PMOS W=1u L=1u
M3 2 9 17 17 NMOS W=1u L=1u
M4 14 10 3 3 NMOS W=1u L=1u
M2 17 6 3 3 NMOS W=1u L=1u
M5 12 11 VDD 18 18 PMOS W=1u L=1u
M7 16 11 VDD VDD PMOS W=1u L=1u
.MODEL NMOS NMOS (LEVEL=1 VTO=1 KP=1.0e-4 LAMBDA=0.02)
.MODEL PMOS PMOS (LEVEL=1 VTO=1 KP=1.0e-4 LAMBDA=0.02)

.OP
.END
