*SPICE Netlist for circuit 190
M3 1 2 0 0 NMOS W=1u L=1u
M2 4 3 1 1 NMOS W=1u L=1u
M1 5 3 1 1 NMOS W=1u L=1u
R1 4 VDD 1k
R2 5 VDD 1k
.MODEL NMOS NMOS (LEVEL=1 VTO=1 KP=1.0e-4 LAMBDA=0.02)

.OP
.END
