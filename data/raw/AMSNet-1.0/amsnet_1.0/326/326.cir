*SPICE Netlist for circuit 326
M1 2 2 0 0 NMOS W=1u L=1u
M2 1 2 0 0 NMOS W=1u L=1u
M3 2 1 VDD VDD NMOS W=1u L=1u
M4 1 1 VDD VDD PMOS W=1u L=1u
R1 2 VDD 1k
.MODEL NMOS NMOS (LEVEL=1 VTO=1 KP=1.0e-4 LAMBDA=0.02)
.MODEL PMOS PMOS (LEVEL=1 VTO=1 KP=1.0e-4 LAMBDA=0.02)

.OP
.END
