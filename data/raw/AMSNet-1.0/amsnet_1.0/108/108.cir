*SPICE Netlist for circuit 108
I1 1 0 DC 1mA
R1 0 1 1k
M1 VDD 4 1 1 NMOS W=1u L=1u
.MODEL NMOS NMOS (LEVEL=1 VTO=1 KP=1.0e-4 LAMBDA=0.02)

.OP
.END
