*SPICE Netlist for circuit 37
V1 4 0 5V
R1 0 2 1k
M1 2 1 4 4 PMOS W=1u L=1u
.MODEL PMOS PMOS (LEVEL=1 VTO=1 KP=1.0e-4 LAMBDA=0.02)

.OP
.END
