*SPICE Netlist for circuit 375
L1 1 2 1uH
R1 1 4 1k
R2 1 2 1k

.OP
.END
