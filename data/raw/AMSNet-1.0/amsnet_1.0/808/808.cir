*SPICE Netlist for circuit 808
I1 2 0 DC 1mA
M3 VDD VDD 1 1 NMOS W=1u L=1u
M4 1 6 2 2 NMOS W=1u L=1u
M2 3 7 2 2 NMOS W=1u L=1u
M1 VDD VDD 3 3 NMOS W=1u L=1u
.MODEL NMOS NMOS (LEVEL=1 VTO=1 KP=1.0e-4 LAMBDA=0.02)

.OP
.END
