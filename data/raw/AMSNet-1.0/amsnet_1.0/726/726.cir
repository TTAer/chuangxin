*SPICE Netlist for circuit 726
C1 0 4 1nF
C2 2 VDD 1nF
C3 10 4 1nF
M5 10 7 2 2 PMOS W=1u L=1u
I1 7 0 DC 1mA
M1 4 1 0 0 NMOS W=1u L=1u
M4 4 2 VDD VDD PMOS W=1u L=1u
M3 7 7 6 6 PMOS W=1u L=1u
M2 6 6 VDD VDD PMOS W=1u L=1u
.MODEL NMOS NMOS (LEVEL=1 VTO=1 KP=1.0e-4 LAMBDA=0.02)
.MODEL PMOS PMOS (LEVEL=1 VTO=1 KP=1.0e-4 LAMBDA=0.02)

.OP
.END
