*SPICE Netlist for circuit 670
I1 3 0 DC 1mA
R2 0 3 1k
R3 0 1 1k
R1 2 0 1k
M1 2 0 6 6 NMOS W=1u L=1u
M3 1 0 2 2 PMOS W=1u L=1u
M2 6 5 3 3 NMOS W=1u L=1u
.MODEL NMOS NMOS (LEVEL=1 VTO=1 KP=1.0e-4 LAMBDA=0.02)
.MODEL PMOS PMOS (LEVEL=1 VTO=1 KP=1.0e-4 LAMBDA=0.02)

.OP
.END
