*SPICE Netlist for circuit 464
C1 0 2 1nF
I1 2 0 DC 1mA
V1 4 0 5V
R1 4 2 1k

.OP
.END
