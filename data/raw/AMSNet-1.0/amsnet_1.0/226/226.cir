*SPICE Netlist for circuit 226
I1 2 0 DC 1mA
M1 6 1 12 13 13 NMOS W=1u L=1u
M4 12 9 2 2 NMOS W=1u L=1u
M2 14 10 2 2 NMOS W=1u L=1u
M5 15 3 VDD 16 16 PMOS W=1u L=1u
M6 6 4 15 17 17 PMOS W=1u L=1u
M8 5 4 18 18 PMOS W=1u L=1u
M3 5 1 14 14 NMOS W=1u L=1u
M7 18 3 VDD VDD PMOS W=1u L=1u
.MODEL NMOS NMOS (LEVEL=1 VTO=1 KP=1.0e-4 LAMBDA=0.02)
.MODEL PMOS PMOS (LEVEL=1 VTO=1 KP=1.0e-4 LAMBDA=0.02)

.OP
.END
