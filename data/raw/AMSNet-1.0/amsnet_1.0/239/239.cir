*SPICE Netlist for circuit 239
M3 1 3 0 0 NMOS W=1u L=1u
M2 6 11 1 1 NMOS W=1u L=1u
M1 4 9 1 1 NMOS W=1u L=1u
M4 6 2 VDD 12 12 PMOS W=1u L=1u
M5 4 2 VDD VDD PMOS W=1u L=1u
R1 6 4 1k
.MODEL NMOS NMOS (LEVEL=1 VTO=1 KP=1.0e-4 LAMBDA=0.02)
.MODEL PMOS PMOS (LEVEL=1 VTO=1 KP=1.0e-4 LAMBDA=0.02)

.OP
.END
