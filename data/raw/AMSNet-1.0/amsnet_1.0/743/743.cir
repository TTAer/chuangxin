*SPICE Netlist for circuit 743
I1 VDD 1 DC 1mA
I2 VDD 3 DC 1mA
I3 2 0 DC 1mA
I4 0 1 DC 1mA
M2 3 1 0 0 NMOS W=1u L=1u
M1 1 2 0 0 NMOS W=1u L=1u
M3 2 3 VDD VDD PMOS W=1u L=1u
.MODEL NMOS NMOS (LEVEL=1 VTO=1 KP=1.0e-4 LAMBDA=0.02)
.MODEL PMOS PMOS (LEVEL=1 VTO=1 KP=1.0e-4 LAMBDA=0.02)

.OP
.END
