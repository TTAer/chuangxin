*SPICE Netlist for circuit 616
I1 5 0 DC 1mA
R1 0 3 1k
M3 6 1 VDD VDD PMOS W=1u L=1u
R2 2 4 1k
R3 4 3 1k
M4 3 6 VDD VDD PMOS W=1u L=1u
M1 VDD 4 5 5 NMOS W=1u L=1u
M2 6 8 5 5 NMOS W=1u L=1u
.MODEL NMOS NMOS (LEVEL=1 VTO=1 KP=1.0e-4 LAMBDA=0.02)
.MODEL PMOS PMOS (LEVEL=1 VTO=1 KP=1.0e-4 LAMBDA=0.02)

.OP
.END
