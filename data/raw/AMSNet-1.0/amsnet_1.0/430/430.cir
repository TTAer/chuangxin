*SPICE Netlist for circuit 430
I1 1 2 DC 1mA
R1 1 2 1k

.OP
.END
