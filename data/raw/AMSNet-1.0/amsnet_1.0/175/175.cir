*SPICE Netlist for circuit 175
M2 1 1 0 0 NMOS W=1u L=1u
M1 2 4 1 1 NMOS W=1u L=1u
M3 2 2 VDD VDD PMOS W=1u L=1u
.MODEL NMOS NMOS (LEVEL=1 VTO=1 KP=1.0e-4 LAMBDA=0.02)
.MODEL PMOS PMOS (LEVEL=1 VTO=1 KP=1.0e-4 LAMBDA=0.02)

.OP
.END
