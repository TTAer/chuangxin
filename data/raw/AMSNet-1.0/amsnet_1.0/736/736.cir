*SPICE Netlist for circuit 736
C1 4 5 1nF
I1 VDD 4 DC 1mA
I2 VDD 5 DC 1mA
I3 2 0 DC 1mA
I4 3 0 DC 1mA
M2 5 2 0 0 NMOS W=1u L=1u
M3 7 1 4 4 PMOS W=1u L=1u
M1 2 8 3 3 NMOS W=1u L=1u
.MODEL NMOS NMOS (LEVEL=1 VTO=1 KP=1.0e-4 LAMBDA=0.02)
.MODEL PMOS PMOS (LEVEL=1 VTO=1 KP=1.0e-4 LAMBDA=0.02)

.OP
.END
