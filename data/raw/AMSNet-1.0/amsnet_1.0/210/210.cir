*SPICE Netlist for circuit 210
R1 0 2 1k
M2 3 1 2 2 NMOS W=1u L=1u
M1 4 1 2 2 NMOS W=1u L=1u
R2 3 VDD 1k
R3 4 VDD 1k
.MODEL NMOS NMOS (LEVEL=1 VTO=1 KP=1.0e-4 LAMBDA=0.02)

.OP
.END
