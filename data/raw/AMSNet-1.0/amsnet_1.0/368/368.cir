*SPICE Netlist for circuit 368
C1 0 1 1nF
I1 1 0 DC 1mA
V1 4 0 5V
M1 VDD 5 1 1 NMOS W=1u L=1u
R1 4 5 1k
.MODEL NMOS NMOS (LEVEL=1 VTO=1 KP=1.0e-4 LAMBDA=0.02)

.OP
.END
