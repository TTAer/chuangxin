*SPICE Netlist for circuit 388
C1 0 3 1nF
C2 4 1 1nF
M1 1 4 0 0 NMOS W=1u L=1u
R1 0 3 1k
.MODEL NMOS NMOS (LEVEL=1 VTO=1 KP=1.0e-4 LAMBDA=0.02)

.OP
.END
