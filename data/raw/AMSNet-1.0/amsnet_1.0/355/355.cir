*SPICE Netlist for circuit 355
I1 4 0 DC 1mA
I2 2 0 DC 1mA
M4 1 4 VDD VDD PMOS W=1u L=1u
M1 1 6 2 2 NMOS W=1u L=1u
M2 VDD 7 2 2 NMOS W=1u L=1u
M3 4 4 VDD VDD NMOS W=1u L=1u
.MODEL NMOS NMOS (LEVEL=1 VTO=1 KP=1.0e-4 LAMBDA=0.02)
.MODEL PMOS PMOS (LEVEL=1 VTO=1 KP=1.0e-4 LAMBDA=0.02)

.OP
.END
