*SPICE Netlist for circuit 805
I1 2 0 DC 1mA
R1 1 VDD 1k
M2 1 6 9 9 NMOS W=1u L=1u
R4 9 2 1k
R3 2 10 1k
R2 3 VDD 1k
M1 3 7 10 10 NMOS W=1u L=1u
.MODEL NMOS NMOS (LEVEL=1 VTO=1 KP=1.0e-4 LAMBDA=0.02)

.OP
.END
