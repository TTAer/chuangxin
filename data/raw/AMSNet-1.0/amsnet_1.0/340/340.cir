*SPICE Netlist for circuit 340
C1 2 4 1nF
M2 4 2 0 0 NMOS W=1u L=1u
M1 2 2 0 0 NMOS W=1u L=1u
R1 2 VDD 1k
.MODEL NMOS NMOS (LEVEL=1 VTO=1 KP=1.0e-4 LAMBDA=0.02)

.OP
.END
