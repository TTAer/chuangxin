*SPICE Netlist for circuit 792
V1 1 0 5V
V2 2 0 5V
R1 2 1 1k

.OP
.END
