*SPICE Netlist for circuit 797
C1 14 3 1nF
C2 4 11 1nF
C3 7 14 1nF
C4 6 11 1nF
I1 5 0 DC 1mA
M3 3 1 VDD 25 25 PMOS W=1u L=1u
M2 3 14 5 5 NMOS W=1u L=1u
M1 4 11 5 5 NMOS W=1u L=1u
M4 4 1 VDD VDD PMOS W=1u L=1u
.MODEL NMOS NMOS (LEVEL=1 VTO=1 KP=1.0e-4 LAMBDA=0.02)
.MODEL PMOS PMOS (LEVEL=1 VTO=1 KP=1.0e-4 LAMBDA=0.02)

.OP
.END
