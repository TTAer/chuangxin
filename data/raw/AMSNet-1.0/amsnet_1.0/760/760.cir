*SPICE Netlist for circuit 760
I1 VDD 2 DC 1mA
M1 3 2 0 6 6 NMOS W=1u L=1u
M3 4 2 0 0 NMOS W=1u L=1u
M2 2 2 0 0 NMOS W=1u L=1u
.MODEL NMOS NMOS (LEVEL=1 VTO=1 KP=1.0e-4 LAMBDA=0.02)

.OP
.END
