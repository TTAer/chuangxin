*SPICE Netlist for circuit 633
I1 VDD 3 DC 1mA
I2 1 0 DC 1mA
M2 1 5 VDD VDD PMOS W=1u L=1u
M1 3 2 1 1 NMOS W=1u L=1u
.MODEL NMOS NMOS (LEVEL=1 VTO=1 KP=1.0e-4 LAMBDA=0.02)
.MODEL PMOS PMOS (LEVEL=1 VTO=1 KP=1.0e-4 LAMBDA=0.02)

.OP
.END
