*SPICE Netlist for circuit 297
I1 2 0 DC 1mA
M1 1 3 2 2 NMOS W=1u L=1u
V2 3 0 5V
R1 1 VDD 1k
M2 1 4 VDD VDD PMOS W=1u L=1u
V1 VDD 4 5V
.MODEL NMOS NMOS (LEVEL=1 VTO=1 KP=1.0e-4 LAMBDA=0.02)
.MODEL PMOS PMOS (LEVEL=1 VTO=1 KP=1.0e-4 LAMBDA=0.02)

.OP
.END
