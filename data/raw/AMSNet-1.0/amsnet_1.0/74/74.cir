*SPICE Netlist for circuit 74
I1 1 4 DC 1mA
I2 1 4 DC 1mA
V1 4 0 5V
R1 4 1 1k

.OP
.END
