*SPICE Netlist for circuit 722
C1 1 VDD 1nF
C2 2 1 1nF
C3 0 2 1nF
V1 5 0 5V
R1 0 2 1k
R2 5 1 1k
M1 2 1 VDD VDD PMOS W=1u L=1u
.MODEL PMOS PMOS (LEVEL=1 VTO=1 KP=1.0e-4 LAMBDA=0.02)

.OP
.END
