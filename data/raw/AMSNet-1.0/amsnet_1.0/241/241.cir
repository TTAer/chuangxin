*SPICE Netlist for circuit 241
M3 1 2 0 0 NMOS W=1u L=1u
M2 6 10 1 1 NMOS W=1u L=1u
M1 4 8 1 1 NMOS W=1u L=1u
M5 3 4 VDD VDD PMOS W=1u L=1u
R2 4 3 1k
M4 5 6 VDD VDD PMOS W=1u L=1u
R1 6 5 1k
.MODEL NMOS NMOS (LEVEL=1 VTO=1 KP=1.0e-4 LAMBDA=0.02)
.MODEL PMOS PMOS (LEVEL=1 VTO=1 KP=1.0e-4 LAMBDA=0.02)

.OP
.END
