*SPICE Netlist for circuit 62
C1 1 3 1nF
M1 VDD 3 1 1 NMOS W=1u L=1u
C2 1 2 1nF
I1 1 0 DC 1mA
.MODEL NMOS NMOS (LEVEL=1 VTO=1 KP=1.0e-4 LAMBDA=0.02)

.OP
.END
