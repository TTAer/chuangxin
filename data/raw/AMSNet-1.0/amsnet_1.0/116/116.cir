*SPICE Netlist for circuit 116
M1 0 3 1 1 PMOS W=1u L=1u
R1 0 1 1k
V1 3 0 5V
.MODEL PMOS PMOS (LEVEL=1 VTO=1 KP=1.0e-4 LAMBDA=0.02)

.OP
.END
