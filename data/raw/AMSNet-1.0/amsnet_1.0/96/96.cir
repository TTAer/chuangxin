*SPICE Netlist for circuit 96
I1 VDD 1 DC 1mA
R1 0 4 1k
M1 1 3 4 4 NMOS W=1u L=1u
.MODEL NMOS NMOS (LEVEL=1 VTO=1 KP=1.0e-4 LAMBDA=0.02)

.OP
.END
