*SPICE Netlist for circuit 752
I1 VDD 5 DC 1mA
M2 5 2 1 1 NMOS W=1u L=1u
I2 VDD 6 DC 1mA
M1 6 3 1 1 NMOS W=1u L=1u
I3 1 0 DC 1mA
.MODEL NMOS NMOS (LEVEL=1 VTO=1 KP=1.0e-4 LAMBDA=0.02)

.OP
.END
