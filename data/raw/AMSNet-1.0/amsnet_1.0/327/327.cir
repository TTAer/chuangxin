*SPICE Netlist for circuit 327
M2 1 1 0 0 NMOS W=1u L=1u
M3 3 1 0 0 NMOS W=1u L=1u
M1 VDD 3 1 1 NMOS W=1u L=1u
R2 3 VDD 1k
R1 1 VDD 1k
.MODEL NMOS NMOS (LEVEL=1 VTO=1 KP=1.0e-4 LAMBDA=0.02)

.OP
.END
