*SPICE Netlist for circuit 693
C1 0 2 1nF
C2 0 7 1nF
M6 7 4 8 8 PMOS W=1u L=1u
I1 1 0 DC 1mA
M2 9 3 1 1 NMOS W=1u L=1u
M4 2 4 10 11 11 PMOS W=1u L=1u
M1 2 5 9 9 NMOS W=1u L=1u
M3 10 6 VDD 12 12 PMOS W=1u L=1u
M5 8 6 VDD VDD PMOS W=1u L=1u
.MODEL NMOS NMOS (LEVEL=1 VTO=1 KP=1.0e-4 LAMBDA=0.02)
.MODEL PMOS PMOS (LEVEL=1 VTO=1 KP=1.0e-4 LAMBDA=0.02)

.OP
.END
