*SPICE Netlist for circuit 695
C1 0 2 1nF
M7 3 30 VDD VDD NMOS W=1u L=1u
M4 9 43 44 44 NMOS W=1u L=1u
M5 45 5 0 0 NMOS W=1u L=1u
M6 44 46 0 0 NMOS W=1u L=1u
M1 4 17 1 1 NMOS W=1u L=1u
M2 17 39 4 4 NMOS W=1u L=1u
M3 5 40 43 43 NMOS W=1u L=1u
.MODEL NMOS NMOS (LEVEL=1 VTO=1 KP=1.0e-4 LAMBDA=0.02)

.OP
.END
