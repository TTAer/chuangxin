*SPICE Netlist for circuit 702
C1 0 2 1nF
M1 3 6 0 8 8 NMOS W=1u L=1u
M2 2 6 0 0 NMOS W=1u L=1u
M3 3 3 VDD VDD PMOS W=1u L=1u
M4 2 3 VDD VDD PMOS W=1u L=1u
.MODEL NMOS NMOS (LEVEL=1 VTO=1 KP=1.0e-4 LAMBDA=0.02)
.MODEL PMOS PMOS (LEVEL=1 VTO=1 KP=1.0e-4 LAMBDA=0.02)

.OP
.END
