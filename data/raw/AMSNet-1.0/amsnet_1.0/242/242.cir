*SPICE Netlist for circuit 242
M3 2 1 0 0 NMOS W=1u L=1u
M2 5 14 2 2 NMOS W=1u L=1u
M1 6 12 2 2 NMOS W=1u L=1u
M7 5 3 VDD VDD PMOS W=1u L=1u
M5 6 4 VDD VDD PMOS W=1u L=1u
M6 5 5 VDD VDD PMOS W=1u L=1u
M4 6 6 VDD VDD PMOS W=1u L=1u
.MODEL NMOS NMOS (LEVEL=1 VTO=1 KP=1.0e-4 LAMBDA=0.02)
.MODEL PMOS PMOS (LEVEL=1 VTO=1 KP=1.0e-4 LAMBDA=0.02)

.OP
.END
