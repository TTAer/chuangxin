*SPICE Netlist for circuit 153
M1 1 4 0 0 NMOS W=1u L=1u
R2 2 1 1k
M2 1 2 VDD VDD PMOS W=1u L=1u
R1 2 VDD 1k
.MODEL NMOS NMOS (LEVEL=1 VTO=1 KP=1.0e-4 LAMBDA=0.02)
.MODEL PMOS PMOS (LEVEL=1 VTO=1 KP=1.0e-4 LAMBDA=0.02)

.OP
.END
