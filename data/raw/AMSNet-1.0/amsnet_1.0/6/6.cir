*SPICE Netlist for circuit 6
I1 1 0 DC 1mA

.OP
.END
