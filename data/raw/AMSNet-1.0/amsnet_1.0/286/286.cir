*SPICE Netlist for circuit 286
I1 3 0 DC 1mA
I2 2 0 DC 1mA
M3 4 3 VDD VDD NMOS W=1u L=1u
M4 5 3 VDD VDD PMOS W=1u L=1u
M2 4 8 2 2 NMOS W=1u L=1u
M1 5 7 2 2 NMOS W=1u L=1u
R1 4 3 1k
.MODEL NMOS NMOS (LEVEL=1 VTO=1 KP=1.0e-4 LAMBDA=0.02)
.MODEL PMOS PMOS (LEVEL=1 VTO=1 KP=1.0e-4 LAMBDA=0.02)

.OP
.END
