*SPICE Netlist for circuit 129
I1 4 0 DC 1mA
M1 1 3 4 4 NMOS W=1u L=1u
R1 1 VDD 1k
.MODEL NMOS NMOS (LEVEL=1 VTO=1 KP=1.0e-4 LAMBDA=0.02)

.OP
.END
