*SPICE Netlist for circuit 403
C1 0 1 1nF
C2 0 2 1nF
R1 4 1 1k
R2 1 2 1k

.OP
.END
