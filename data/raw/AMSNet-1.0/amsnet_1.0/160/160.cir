*SPICE Netlist for circuit 160
R2 2 1 1k
M1 1 2 VDD VDD PMOS W=1u L=1u
R1 2 VDD 1k
.MODEL PMOS PMOS (LEVEL=1 VTO=1 KP=1.0e-4 LAMBDA=0.02)

.OP
.END
