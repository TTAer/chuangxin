*SPICE Netlist for circuit 27
M1 4 1 5 5 PMOS W=1u L=1u
V1 5 0 5V
V2 4 0 5V
.MODEL PMOS PMOS (LEVEL=1 VTO=1 KP=1.0e-4 LAMBDA=0.02)

.OP
.END
