*SPICE Netlist for circuit 593
I1 1 2 DC 1mA
R2 0 2 1k
M1 VDD 1 2 2 NMOS W=1u L=1u
R1 1 VDD 1k
.MODEL NMOS NMOS (LEVEL=1 VTO=1 KP=1.0e-4 LAMBDA=0.02)

.OP
.END
