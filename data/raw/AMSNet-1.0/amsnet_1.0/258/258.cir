*SPICE Netlist for circuit 258
I1 VDD 4 DC 1mA
M2 2 1 6 6 NMOS W=1u L=1u
M1 4 4 0 0 NMOS W=1u L=1u
M3 6 4 0 0 NMOS W=1u L=1u
.MODEL NMOS NMOS (LEVEL=1 VTO=1 KP=1.0e-4 LAMBDA=0.02)

.OP
.END
