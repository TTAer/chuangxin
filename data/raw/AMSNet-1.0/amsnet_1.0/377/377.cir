*SPICE Netlist for circuit 377
C1 1 2 1nF
C2 0 1 1nF
M2 1 5 0 0 NMOS W=1u L=1u
M1 VDD 2 1 1 NMOS W=1u L=1u
R1 VDD 2 1k
.MODEL NMOS NMOS (LEVEL=1 VTO=1 KP=1.0e-4 LAMBDA=0.02)

.OP
.END
