*SPICE Netlist for circuit 687
C1 0 9 1nF
R2 0 4 1k
M3 1 1 VDD VDD NMOS W=1u L=1u
M1 3 1 VDD VDD NMOS W=1u L=1u
M2 1 8 2 2 NMOS W=1u L=1u
R1 4 3 1k
.MODEL NMOS NMOS (LEVEL=1 VTO=1 KP=1.0e-4 LAMBDA=0.02)

.OP
.END
