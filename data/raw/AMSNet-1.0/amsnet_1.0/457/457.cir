*SPICE Netlist for circuit 457
V1 10 0 5V

.OP
.END
