*SPICE Netlist for circuit 717
I1 VDD 7 DC 1mA
I2 VDD 26 DC 1mA
M3 4 9 0 0 NMOS W=1u L=1u
M4 3 11 0 0 NMOS W=1u L=1u
M1 9 2 0 27 27 NMOS W=1u L=1u
M5 11 2 0 0 NMOS W=1u L=1u
M9 3 1 VDD VDD PMOS W=1u L=1u
M7 4 5 VDD VDD PMOS W=1u L=1u
M6 3 13 7 28 28 PMOS W=1u L=1u
M10 9 13 8 8 PMOS W=1u L=1u
M8 11 15 8 8 PMOS W=1u L=1u
M2 4 15 26 29 29 NMOS W=1u L=1u
.MODEL NMOS NMOS (LEVEL=1 VTO=1 KP=1.0e-4 LAMBDA=0.02)
.MODEL PMOS PMOS (LEVEL=1 VTO=1 KP=1.0e-4 LAMBDA=0.02)

.OP
.END
