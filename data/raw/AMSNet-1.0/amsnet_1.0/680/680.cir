*SPICE Netlist for circuit 680
I1 13 0 DC 1mA
M1 5 3 13 13 NMOS W=1u L=1u
M2 6 2 0 0 NMOS W=1u L=1u
M3 5 1 VDD VDD PMOS W=1u L=1u
M4 6 5 VDD VDD PMOS W=1u L=1u
R1 9 6 1k
.MODEL NMOS NMOS (LEVEL=1 VTO=1 KP=1.0e-4 LAMBDA=0.02)
.MODEL PMOS PMOS (LEVEL=1 VTO=1 KP=1.0e-4 LAMBDA=0.02)

.OP
.END
