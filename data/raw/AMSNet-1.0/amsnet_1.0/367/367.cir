*SPICE Netlist for circuit 367
C1 0 2 1nF
C2 3 2 1nF
M1 2 3 0 0 NMOS W=1u L=1u
V1 3 0 5V
R1 2 VDD 1k
.MODEL NMOS NMOS (LEVEL=1 VTO=1 KP=1.0e-4 LAMBDA=0.02)

.OP
.END
