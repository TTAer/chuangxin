*SPICE Netlist for circuit 786
C1 0 2 1nF
M2 4 1 2 2 PMOS W=1u L=1u
M1 2 3 4 4 NMOS W=1u L=1u
.MODEL NMOS NMOS (LEVEL=1 VTO=1 KP=1.0e-4 LAMBDA=0.02)
.MODEL PMOS PMOS (LEVEL=1 VTO=1 KP=1.0e-4 LAMBDA=0.02)

.OP
.END
