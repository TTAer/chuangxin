*SPICE Netlist for circuit 135
I1 VDD 2 DC 1mA
M1 2 1 4 4 NMOS W=1u L=1u
R1 4 2 1k
R2 6 4 1k
M2 4 7 6 6 NMOS W=1u L=1u
.MODEL NMOS NMOS (LEVEL=1 VTO=1 KP=1.0e-4 LAMBDA=0.02)

.OP
.END
