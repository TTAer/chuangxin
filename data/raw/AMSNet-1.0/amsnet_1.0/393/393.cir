*SPICE Netlist for circuit 393
C1 0 1 1nF
R1 0 1 1k
M2 3 5 0 0 NMOS W=1u L=1u
M3 1 3 VDD VDD PMOS W=1u L=1u
M1 3 3 VDD 6 6 NMOS W=1u L=1u
.MODEL NMOS NMOS (LEVEL=1 VTO=1 KP=1.0e-4 LAMBDA=0.02)
.MODEL PMOS PMOS (LEVEL=1 VTO=1 KP=1.0e-4 LAMBDA=0.02)

.OP
.END
