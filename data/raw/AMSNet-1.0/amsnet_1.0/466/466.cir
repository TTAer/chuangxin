*SPICE Netlist for circuit 466
I1 VDD 4 DC 1mA
I2 4 2 DC 1mA
R1 4 VDD 1k
M1 4 3 2 2 NMOS W=1u L=1u
.MODEL NMOS NMOS (LEVEL=1 VTO=1 KP=1.0e-4 LAMBDA=0.02)

.OP
.END
