*SPICE Netlist for circuit 420
C1 1 2 1nF
C2 0 3 1nF
M2 1 3 0 0 NMOS W=1u L=1u
R2 3 1 1k
M1 5 7 1 1 NMOS W=1u L=1u
M3 5 2 VDD VDD NMOS W=1u L=1u
R1 2 4 1k
.MODEL NMOS NMOS (LEVEL=1 VTO=1 KP=1.0e-4 LAMBDA=0.02)

.OP
.END
