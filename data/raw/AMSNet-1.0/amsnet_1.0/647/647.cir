*SPICE Netlist for circuit 647
I1 4 0 DC 1mA
M2 6 6 0 0 NMOS W=1u L=1u
M4 5 6 0 0 NMOS W=1u L=1u
M6 6 2 VDD VDD NMOS W=1u L=1u
M5 2 1 VDD VDD NMOS W=1u L=1u
M3 2 10 4 4 NMOS W=1u L=1u
M7 7 1 VDD VDD PMOS W=1u L=1u
M1 7 11 4 4 NMOS W=1u L=1u
M8 5 7 VDD VDD PMOS W=1u L=1u
.MODEL NMOS NMOS (LEVEL=1 VTO=1 KP=1.0e-4 LAMBDA=0.02)
.MODEL PMOS PMOS (LEVEL=1 VTO=1 KP=1.0e-4 LAMBDA=0.02)

.OP
.END
