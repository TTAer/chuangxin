*SPICE Netlist for circuit 52
C1 2 1 1nF
V1 2 0 5V
M1 1 VDD 2 2 NMOS W=1u L=1u
.MODEL NMOS NMOS (LEVEL=1 VTO=1 KP=1.0e-4 LAMBDA=0.02)

.OP
.END
