*SPICE Netlist for circuit 714
M2 4 6 0 0 NMOS W=1u L=1u
M1 3 3 0 0 NMOS W=1u L=1u
M3 6 3 0 0 NMOS W=1u L=1u
M4 2 1 VDD 12 12 PMOS W=1u L=1u
M7 3 8 2 2 PMOS W=1u L=1u
M5 6 9 2 2 PMOS W=1u L=1u
M6 4 1 VDD VDD PMOS W=1u L=1u
.MODEL NMOS NMOS (LEVEL=1 VTO=1 KP=1.0e-4 LAMBDA=0.02)
.MODEL PMOS PMOS (LEVEL=1 VTO=1 KP=1.0e-4 LAMBDA=0.02)

.OP
.END
