*SPICE Netlist for circuit 790
C1 0 3 1nF
C2 0 2 1nF
C3 3 4 1nF
C4 3 1nF
I1 4 0 DC 1mA
V1 6 0 5V
R1 0 2 1k

.OP
.END
