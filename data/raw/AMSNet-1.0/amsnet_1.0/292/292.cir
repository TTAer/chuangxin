*SPICE Netlist for circuit 292
R1 0 3 1k
M3 1 1 VDD VDD NMOS W=1u L=1u
M4 2 1 VDD VDD PMOS W=1u L=1u
M1 2 4 3 3 NMOS W=1u L=1u
M2 1 4 3 3 NMOS W=1u L=1u
.MODEL NMOS NMOS (LEVEL=1 VTO=1 KP=1.0e-4 LAMBDA=0.02)
.MODEL PMOS PMOS (LEVEL=1 VTO=1 KP=1.0e-4 LAMBDA=0.02)

.OP
.END
