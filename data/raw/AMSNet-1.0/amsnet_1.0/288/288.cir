*SPICE Netlist for circuit 288
R1 0 3 1k
M4 1 2 VDD VDD PMOS W=1u L=1u
M2 1 7 3 3 NMOS W=1u L=1u
M3 1 2 VDD VDD PMOS W=1u L=1u
M1 1 7 3 8 8 NMOS W=1u L=1u
.MODEL NMOS NMOS (LEVEL=1 VTO=1 KP=1.0e-4 LAMBDA=0.02)
.MODEL PMOS PMOS (LEVEL=1 VTO=1 KP=1.0e-4 LAMBDA=0.02)

.OP
.END
