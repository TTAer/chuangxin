*SPICE Netlist for circuit 269
I1 3 0 DC 1mA
I2 2 0 DC 1mA
M3 3 3 VDD VDD NMOS W=1u L=1u
M4 4 3 VDD VDD PMOS W=1u L=1u
M2 VDD 6 2 2 NMOS W=1u L=1u
M1 4 7 2 2 NMOS W=1u L=1u
.MODEL NMOS NMOS (LEVEL=1 VTO=1 KP=1.0e-4 LAMBDA=0.02)
.MODEL PMOS PMOS (LEVEL=1 VTO=1 KP=1.0e-4 LAMBDA=0.02)

.OP
.END
