*SPICE Netlist for circuit 351
C1 7 2 1nF
I1 5 0 DC 1mA
M4 2 3 VDD VDD PMOS W=1u L=1u
M1 2 1 5 5 NMOS W=1u L=1u
M3 7 3 VDD VDD NMOS W=1u L=1u
M2 7 1 5 5 NMOS W=1u L=1u
.MODEL NMOS NMOS (LEVEL=1 VTO=1 KP=1.0e-4 LAMBDA=0.02)
.MODEL PMOS PMOS (LEVEL=1 VTO=1 KP=1.0e-4 LAMBDA=0.02)

.OP
.END
