*SPICE Netlist for circuit 68
I1 1 2 DC 1mA
V1 5 0 5V
R1 0 1 1k
R2 0 1 1k

.OP
.END
