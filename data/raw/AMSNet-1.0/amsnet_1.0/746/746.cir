*SPICE Netlist for circuit 746
M3 9 9 0 0 NMOS W=1u L=1u
M6 4 9 0 0 NMOS W=1u L=1u
M8 6 1 16 17 17 PMOS W=1u L=1u
M1 6 2 18 19 19 NMOS W=1u L=1u
M9 7 7 VDD VDD PMOS W=1u L=1u
M7 16 7 VDD 20 20 PMOS W=1u L=1u
M5 18 13 4 4 NMOS W=1u L=1u
M2 21 11 4 4 NMOS W=1u L=1u
M11 8 1 22 22 PMOS W=1u L=1u
M4 8 2 21 21 NMOS W=1u L=1u
M10 22 7 VDD VDD PMOS W=1u L=1u
.MODEL NMOS NMOS (LEVEL=1 VTO=1 KP=1.0e-4 LAMBDA=0.02)
.MODEL PMOS PMOS (LEVEL=1 VTO=1 KP=1.0e-4 LAMBDA=0.02)

.OP
.END
